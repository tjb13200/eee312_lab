<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Lab 2\Lab2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Lab 3\Lab3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


